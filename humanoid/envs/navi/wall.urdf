Commit message: all demo components finished, build emgit add --all

File: humanoid/envs/navi/wall.urdf (robot description, URDF)
Before this commit: robot object, 1 links, 0 joints
Links:
- link object: geometry collision box size=40 0.5 1; visual box size=40 0.5 2.5
